FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRCREV = "41a9a5c7b3674f0fac6d8fa3b633cde17c2df78f"
