SRCREV = "1014f47c7a808e025b8920ab80bfe73a2888b3e5"

FILES_${PN}-misc:append = " ${sbindir}/xen-ucode"
