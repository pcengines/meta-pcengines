PACKAGECONFIG_remove = " sdl"
