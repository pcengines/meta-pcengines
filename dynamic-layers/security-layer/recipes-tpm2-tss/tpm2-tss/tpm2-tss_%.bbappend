FILES_${PN} = "/lib/udev"
EXTRA_OECONF += "--with-udevrulesdir=/lib/udev/rules.d/"
