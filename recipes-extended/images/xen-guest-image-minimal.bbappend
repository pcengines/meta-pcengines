IMAGE_INSTALL_append = " \
  iperf3 \
  openssh \
  bridge-utils \ 
  openvswitch \
  "